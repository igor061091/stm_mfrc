# Keil uVision project project.uvprojx, settings and files
target STM32F1-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: .\User;.\TM;.\STD_Periph_Drivers;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./startup/: startup_stm32f103xb.s
  group STD_Periph_Drivers
    ./STD_Periph_Drivers/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_flash.c
  group TM
    ./TM/: tm_stm32f4_gpio.c tm_stm32f4_mfrc522.c tm_stm32f4_spi.c
  group User
    ./User/: main.h main.c defines.h
